# IAR project Project.ewp, settings and files
configuration BOOT_FLASH (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl7mptnnl8f.h
  General.OGChipSelectEditMenu: STM32F10x ST STM32F10x
  ICCARM.CCDefines: VECT_TAB_FLASH
  ICCARM.CCIncludePath2: ..\; ..\..\..\library\inc; ..\config; ..\bsp; ..\..\..\ucosii; ..\..\..\ucosii_port; ..\..\..\ucosii_buf; ..\..\..\robort; ..\..\..\ps2; ..\..\..\LCD12864; ..\..\..\I2C; ..\..\..\uC-Modbus\Cfg\Template; ..\..\..\uC-Modbus\OS\uCOS-II; ..\..\..\uC-Modbus\Ports\STM32; ..\..\..\uC-Modbus\Source; ..\..\..\VUOper; ..\..\..\AD9850; ..\..\..\UC-7400-modbus; ..\EWARM; ..\..\..\28BYJ-48_step_mot; ..\..\..\i2c
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnkarm_flash.xcl
configuration BOOT_RAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: VECT_TAB_RAM
  ICCARM.CCIncludePath2: ..\; ..\..\..\library\inc; ..\config; ..\bsp; ..\..\..\ucosii; ..\..\..\ucosii_port; ..\..\..\ucosii_buf; ..\..\..\Robort; ..\..\..\LCD12864; ..\..\..\I2C
  XLINK.XclFile: E:\Proj\STM32\PLC\IAR1012\工程文件\UCOS模板\EWARM\lnkarm_flash.xcl
  group config
    ../Config/: app_cfg.h includes.h os_cfg.h stm32f10x_conf.h
    ./: flash_loc.c flash_loc.h
    ../../../uC-Modbus/Cfg/Template/: MB_CFG.H
    ../../../uC-Modbus/OS/uCOS-II/: mb_os.h
  group EWARM
    ./: cortexm3_macro.s stm32f10x_vector.c
  group FWLib
    ../../../library/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_tim1.c stm32f10x_usart.c stm32f10x_wwdg.c
  group I2C
    ../../../i2c/: bsp_i2c_ee.c bsp_i2c_ee.h bsp_i2c_gpio.c bsp_i2c_gpio.h
  group LCD12864
    ../../../LCD12864/: GB_Table.c LCD_ASCII.c LCD_Config.h LCD_Dis.c LCD_Dis.h LCD_Driver_User.c LCD_Driver_User.h LCD_PortConfig.h
  group ps2
    ../../../ps2/: pstwo.c pstwo.h
  group step_28byj_48
    ../../../28BYJ-48_step_mot/: step_28BYJ-48.c
  group UC700Modbus
    ../../../UC-7400-modbus/: mbserial.c modbus_utils.c
  group UCOSII
    ../../../uC-Modbus/Source/: mb.h
    ../../../UCOSII/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group UCOSII_Port
    ../../../UCOSII_PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group User
    ../BSP/: bsp.c bsp.h bsp_rob0.c bsp_rob0.h stm32f10x_it.c stm32f10x_it.h
    ../../../Robort/: rob0.c rob0.h Robot.c Robot.h
  group XCL
    ./: lnkarm_flash.xcl lnkarm_ram.xcl
