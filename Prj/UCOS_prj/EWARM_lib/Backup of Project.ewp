# IAR project Backup of Project.ewp, settings and files
configuration BOOT_FLASH (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl7mptnnl8f.h
  General.OGChipSelectEditMenu: STM32F10x ST STM32F10x
  ICCARM.CCDefines: VECT_TAB_FLASH
  ICCARM.CCIncludePath2: ..\; ..\..\..\library\inc; ..\config; ..\bsp; ..\..\..\ucosii; ..\..\..\ucosii_port; ..\..\..\ucosii_buf; ..\..\..\robort; ..\..\..\LCD12864
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnkarm_flash.xcl
configuration BOOT_RAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: VECT_TAB_RAM
  ICCARM.CCIncludePath2: ..\; ..\..\..\library\inc; ..\config; ..\bsp; ..\..\..\ucosii; ..\..\..\ucosii_port; ..\..\..\ucosii_buf
  XLINK.XclFile: lnkarm_ram.xcl
  group config
    ../Config/: app_cfg.h includes.h os_cfg.h stm32f10x_conf.h
  group EWARM
    ./: cortexm3_macro.s stm32f10x_vector.c
  group FWLib
    ../../../library/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_tim1.c stm32f10x_usart.c stm32f10x_wwdg.c
  group LCD
    ../BSP/: lcd.c lcd.h
  group LCD12864
    ../../../LCD12864/: GB_Table.c LCD_ASCII.c LCD_Config.h LCD_Dis.c LCD_Dis.h LCD_Driver_User.c LCD_Driver_User.h LCD_PortConfig.h
  group UCOSII
    ../../../UCOSII/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group UCOSII_Port
    ../../../UCOSII_PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group User
    ../BSP/: app.c bsp.c bsp.h stm32f10x_it.c stm32f10x_it.h
    ../../../Robort/: Robot.c Robot.h
  group XCL
    ./: lnkarm_flash.xcl lnkarm_ram.xcl
